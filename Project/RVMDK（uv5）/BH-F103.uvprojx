# Keil uVision project BH-F103.uvprojx, settings and files
target MulltiMQ8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MultiMQ8 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\adc;..\..\User\lcd;..\..\User\flash;..\..\User\beep;..\..\User\ESP8266;..\..\User\dwt_delay;..\..\User\Common;..\..\User\system;..\..\User\SysTick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/adc/: bsp_adc.c
    ../../User/usart/: bsp_usart.c
    ../../User/lcd/: bsp_ili9341_lcd.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/font/: fonts.c
    ../../User/beep/: bsp_beep.c
    ../../User/ESP8266/: bsp_esp8266.c bsp_esp8266_test.c
    ../../User/dwt_delay/: core_delay.c
    ../../User/system/: system.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/Common/: Common.c
